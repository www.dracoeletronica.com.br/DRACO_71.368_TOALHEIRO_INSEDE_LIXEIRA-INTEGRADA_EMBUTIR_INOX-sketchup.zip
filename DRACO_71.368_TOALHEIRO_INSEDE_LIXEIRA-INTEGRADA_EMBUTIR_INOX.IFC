Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_71.368_TOALHEIRO_INSEDE_LIXEIRA-INTEGRADA_EMBUTIR_INOX.IFC
Time: 2022-06-09T15:39:25
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: DRACO_71.368_BASE_PAPEL_INOX
In: Default Storey
Material: Steel

# IfcBeam: DRACO_71.368_FUNDO_INOX
In: Default Storey
Material: AISI 304

# IfcBeam: DRACO_71.368_LIXEIRA_INOX
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: DRACO_71.368_PORTA_INOX
In: Default Storey
Material: AISI 304
